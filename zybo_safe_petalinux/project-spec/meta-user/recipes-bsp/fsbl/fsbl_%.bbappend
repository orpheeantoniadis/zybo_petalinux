XSCTH_BUILD_DEBUG = "1"
YAML_COMPILER_FLAGS_append = " -DFSBL_DEBUG_INFO"
